
require include/image-seabot-base.inc
require include/seabot-extrausers.inc
require include/network-config.inc
require include/virtualization.inc
require include/seabot-pkg-conf-base.inc

