RDEPENDS:${PN}:remove = " bash"
RDEPENDS:${PN} = " dash"
