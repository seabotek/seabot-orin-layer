RDEPENDS:${PN}-nvstartup:remove = " bash"
RDEPENDS:${PN}-bootloader:remove = " bash"

RDEPENDS:${PN}-nvstartup = "dash"
RDEPENDS:${PN}-bootloader = "dash"
