FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://orin.cfg"