SUMMARY = "Custom linux image for Jetson ORIN" 
LICENSE = "MIT"
MACHINE = "jetson-orin-nano-devkit"
export IMAGE_BASENAME = "seabot-orin"

